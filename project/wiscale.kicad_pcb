# Repository makerspacelt/WiScale-hw

File README.md:

This is ESP8266 (ESP-12F) and HX711 based weight monitoring device.

* Designed to be pretty small.
* Supports multiple load cells.
* Can be populated with 18650 battery
* Can be operated in ultra low power mode

Dev NOTE: before commit, run `./kibot.sh` to regenerate documentation, bom, gerbers and other assets.

* [schematics.pdf](gen/schematics.pdf)
* [pcb.pdf with dimensions](gen/pcb.pdf)
* [ibom.html](gen/bom_ibom.html)
* [gerbers.zip](gen/gerbers/gerbers.zip)

## Normal operation

The circuit should be powered either via a USB connector on the LiPo charger
or battery.

## Assembly and hardware configuration notes

### LiPo charger

Chargers(U301) with protection can be used.

For use without onboard charger R303 must be shorted and U301,R301 and R302
can be omitted. 

### Low-power sleep

A timer is equipped with selectable(SW301) wake-up settings(R304 and R305).

For applications that do not require a low-power sleep, timer can be bypassed
by shorting out R306. Following components can be omitted in assembly:

* U302
* Q302
* SW301,SW302
* R304,R305,R307,R308

### ADC configuration

To reduce noise on measurements capacitors(C401,C402,C403) on ADC input are
placed. As a side effect, they slow down reading settling time after weight
change. Removing these capacitors will give a fast reading but increase spread
by about 3 times.

## KiCad design project/wiscale.kicad_pcb

Board: 2 copper layers, 100.0 x 50.0 mm, 117 parts (0 on the bottom side), 59 nets.

Parts:
BT301: 18650; BAT_BH-18650-PC
BT302: 801437; BAT_IP801437D3R2
C201, C202, C204, C305, C306, C401, C403, C405, C501, C503, C505, C601, C603, C605, C901: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C203, C301, C302, C307, C308, C404, C407, C504, C507, C604, C607: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C303, C304: 100u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C402, C406, C502, C506, C602, C606: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D201: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D301, D302: 1N4148WL; D_SOD-123
D303: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F301: PTC 1A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
FB401, FB501, FB601: bead; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H101, H102, H103, H104: MountingHole_Pad; MountingHole_3.5mm_Pad_Via
J301: USB_POWER_IN; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J401, J501, J601: cell; JST_XH_S4B-XH-SM4-TB_1x04-1MP_P2.50mm_Horizontal
J701, J801: DS18B20; Jack_3.5mm_Horizontal
J901: i2c; PinSocket_1x04_P2.54mm_Vertical
LOGO101: logo_kms_small; logo_kms_small_silkscreen
LOGO102: Logo_Open_Hardware_Small; OSHW-Symbol_6.7x6mm_SilkScreen
Q301, Q302, Q401, Q501, Q601: AO3401A; SOT-23
R201, R302, R305, R403, R406, R503, R506, R603, R606: 180k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R202, R301: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R203, R205, R206: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R207, R307, R401, R402, R405, R501, R502, R505, R601, R602, R605: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R303, R306: DNP; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R304: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R308, R309, R310, R311, R701, R801, R901, R902: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R404, R504, R604: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW301: SW_SPDT; SW_SPDT_PCM12
SW302: btn; PinHeader_1x02_P2.54mm_Vertical
U201: ESP-7(S) or ESP-12*; ESP-12S
U301: BMS_USB_LiPo_Charger; module_bms_usb_lipo_charger
U302: TPL5110; SOT-23-6
U303: AMS1117-3.3; SOT-223-3_TabPin2
U401, U501, U601: HX711; SOP-16_4.4x10.4mm_P1.27mm
U701, U801: DS18B20Z; SOIC-8_3.9x4.9mm_P1.27mm
U702, U802: DS18B20; TO-92_Inline
kibuzzard-63DFF7BC: G***; kibuzzard-63DFF7BC
kibuzzard-63DFF7CA: G***; kibuzzard-63DFF7CA
kibuzzard-637D024E: G***; kibuzzard-637D024E

Connections:
/ADC1/A+: C402.2, C403.2, R402.1, U401.8 (IN_A+), U401.10 (IN_B+)
/ADC1/A-: C401.1, C402.1, R401.1, U401.7 (IN_A-), U401.9 (IN_B-)
/ADC1/DT: J901.4, R902.1, U201.13 (GPIO4), U401.12 (DOUT)
/ADC1/E+: C404.2, J401.1, Q401.3 (D), R404.1, U401.3 (AVDD)
/ADC1/S+: J401.4, R402.2
/ADC1/S-: J401.3, R401.2
/ADC1/SCK: J901.3, R901.1, U201.14 (GPIO5), U401.11 (SCK)
/ADC1/Vcc: C202.2, C203.2, C204.2, C306.2, C407.2, C507.2, C607.2, C901.2, FB401.1, FB501.1, FB601.1, J701.T, J801.T, J901.2, Q302.3 (D), R201.2, R203.1, R205.2, R207.2, R306.2, R311.2, R701.2, R801.2, R901.2, R902.2, U201.8 (VCC), U401.16 (DVDD), U501.16 (DVDD), U601.16 (DVDD), U701.3 (VDD), U702.3 (VDD), U801.3 (VDD), U802.3 (VDD)
/ADC1/_VFB: R403.1, R404.2, U401.4 (VFB)
/ADC1/_VSUP: C406.2, FB401.2, Q401.2 (S), R406.2, U401.1 (VSUP)
/ADC2/A+: C502.2, C503.2, R502.1, U501.8 (IN_A+), U501.10 (IN_B+)
/ADC2/A-: C501.1, C502.1, R501.1, U501.7 (IN_A-), U501.9 (IN_B-)
/ADC2/DT: R205.1, U201.12 (GPIO0), U501.12 (DOUT)
/ADC2/E+: C504.2, J501.1, Q501.3 (D), R504.1, U501.3 (AVDD)
/ADC2/S+: J501.4, R502.2
/ADC2/S-: J501.3, R501.2
/ADC2/SCK: U201.11 (GPIO2), U501.11 (SCK)
/ADC2/_VFB: R503.1, R504.2, U501.4 (VFB)
/ADC2/_VSUP: C506.2, FB501.2, Q501.2 (S), R506.2, U501.1 (VSUP)
/ADC3/A+: C602.2, C603.2, R602.1, U601.8 (IN_A+), U601.10 (IN_B+)
/ADC3/A-: C601.1, C602.1, R601.1, U601.7 (IN_A-), U601.9 (IN_B-)
/ADC3/DT: U201.4 (GPIO16), U601.12 (DOUT)
/ADC3/E+: C604.2, J601.1, Q601.3 (D), R604.1, U601.3 (AVDD)
/ADC3/S+: J601.4, R602.2
/ADC3/S-: J601.3, R601.2
/ADC3/SCK: R206.2, U201.10 (GPIO15), U601.11 (SCK)
/ADC3/_VFB: R603.1, R604.2, U601.4 (VFB)
/ADC3/_VSUP: C606.2, FB601.2, Q601.2 (S), R606.2, U601.1 (VSUP)
/MCU/1w: J701.R, R701.1, U201.5 (GPIO14), U701.4 (DQ), U702.2 (DQ)
/MCU/Charging: J801.R, R301.1, R302.2, R801.1, U201.7 (GPIO13), U801.4 (DQ), U802.2 (DQ)
/MCU/MCU_DONE: R308.2, U201.6 (GPIO12), U302.4 (DONE)
/MCU/_RST: C204.1, R203.2, U201.1 (~RST), U201.3 (EN)
/MCU/_RX: D201.1 (K), U201.15 (GPIO3/RXD)
/MCU/_adc: C201.2, R201.1, R202.2, U201.2 (ADC)
/PSU/_b+: BT301.1 (+), BT302.1 (+), F301.2
/PSU/_b+_fused: C302.2, F301.1, Q301.3 (D)
/PSU/_b-: BT301.2 (-), BT302.2 (-), C301.1, C302.1, Q301.1 (G), R303.2, U301.b2 (BAT-)
/PSU/_cc1: J301.A5 (CC1), R310.2
/PSU/_cc2: J301.B5 (CC2), R309.2
/PSU/_delay: SW301.2 (B), SW302.1, U302.3 (DELAY/M_DRV)
/PSU/_drv_gate: R307.1, U302.5 (DRV)
/PSU/_fet_gate: Q302.1 (G), R307.2
GND: C201.1, C202.1, C203.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C401.2, C403.1, C404.1, C405.1, C406.1, C407.1, C501.2, C503.1, C504.1, C505.1, C506.1, C507.1, C601.2, C603.1, C604.1, C605.1, C606.1, C607.1, C901.1, D303.1 (K), H101.1, H102.1, H103.1, H104.1, J301.A1 (GND), J301.A12 (GND), J301.B1 (GND), J301.B12 (GND), J301.S1 (SHIELD), J401.2, J401.MP (MountPin), J501.2, J501.MP (MountPin), J601.2, J601.MP (MountPin), J701.S, J801.S, J901.1, R202.1, R206.1, R302.1, R303.1, R304.1, R305.1, R308.1, R309.1, R310.1, R403.2, R503.2, R603.2, SW301.MP, U201.9 (GND), U301.i2 (IN-), U301.o2 (OUT-), U302.2 (GND), U303.1 (GND), U401.5 (AGND), U401.14 (XI), U401.15 (RATE), U501.5 (AGND), U501.14 (XI), U501.15 (RATE), U601.5 (AGND), U601.14 (XI), U601.15 (RATE), U701.5 (GND), U702.1 (GND), U801.5 (GND), U802.1 (GND)
unnamed: C405.2, U401.6 (VBG)
unnamed: C505.2, U501.6 (VBG)
unnamed: C605.2, U601.6 (VBG)
unnamed: D201.2 (A), R207.1
unnamed: D301.1 (K), D302.2 (A)
unnamed: D303.2 (A), R311.1
unnamed: Q401.1 (G), R405.1, R406.1
unnamed: Q501.1 (G), R505.1, R506.1
unnamed: Q601.1 (G), R605.1, R606.1
unnamed: R304.2, SW301.1 (A)
unnamed: R305.2, SW301.3 (C)
unnamed: R405.2, U401.2 (BASE)
unnamed: R505.2, U501.2 (BASE)
unnamed: R605.2, U601.2 (BASE)
Vbat: C301.2, C303.2, C304.2, C305.2, C308.2, D302.1 (K), Q301.2 (S), Q302.2 (S), R306.1, SW302.2, U301.b1 (BAT+), U301.o1 (OUT+), U302.1 (VDD), U302.6 (EN/ONE_SHOT), U303.2 (VO)
Vusb: C307.2, D301.2 (A), J301.A4 (VBUS), J301.A9 (VBUS), J301.B4 (VBUS), J301.B9 (VBUS), R301.2, U301.i1 (IN+), U303.3 (VI)

File gen/bom.csv:

"Row","Description","Part","References","Value","Footprint","Quantity Per PCB","Status","Datasheet","LCSC Part Number","MPN"
"1","Single-cell battery","Battery_Cell","BT301","18650","BAT_BH-18650-PC","1"," ","https://datasheet.lcsc.com/lcsc/2204021730_MYOUNG-BH-18650-B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","C2988620","BH-18650-B1BA002"
"2","Single-cell battery","Battery_Cell","BT302","801437","BAT_IP801437D3R2","1"," ","~","",""
"3","Unpolarized capacitor","C","C201,C202,C204,C305,C306,C401,C403,C405,C501,C503,C505,C601,C603,C605,C901","100n","C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","15"," ","~","",""
"4","Unpolarized capacitor","C","C402,C406,C502,C506,C602,C606","1u","C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","6"," ","~","",""
"5","Unpolarized capacitor","C","C203,C301,C302,C307,C308,C404,C407,C504,C507,C604,C607","10u","C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","11"," ","~","",""
"6","Unpolarized capacitor","C","C303,C304","100u","C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","2"," ","https://datasheet.lcsc.com/lcsc/1811061115_Murata-Electronic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","C312983","GRM31CR61A107ME05L"
"7","","1N4148W","D301,D302","1N4148WL","D_SOD-123","2"," ","https://www.vishay.com/docs/85748/1n4148w.pdf","C2908120",""
"8","Light emitting diode","LED","D201","BLUE","LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder","1"," ","https://datasheet.lcsc.com/lcsc/2211030000_XINGLIGHT-XL-2012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","C965817","XL-2012UBC"
"9","Light emitting diode","LED","D303","GREEN","LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder","1"," ","https://datasheet.lcsc.com/lcsc/2211030000_XINGLIGHT-XL-2012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","C965817","XL-2012UBC"
"10","Resettable fuse, polymeric positive temperature coefficient","Polyfuse","F301","PTC 1A","Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder","1"," ","https://datasheet.lcsc.com/lcsc/2105241640_Jinrui-Electronic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","C2830246","JK-nSMD100/16V"
"11","Ferrite bead","FerriteBead","FB401,FB501,FB601","bead","L_0805_2012Metric_Pad1.15x1.40mm_HandSolder","3"," ","~","",""
"12","Audio Jack, 3 Poles (Stereo / TRS)","AudioJack3","J701,J801","DS18B20","Jack_3.5mm_Horizontal","2"," ","~","",""
"13","Generic connectable mounting pin connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)","Conn_01x03_MountingPin","J1001,J1002,J1003,J1004","TL","JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal","4"," ","~","",""
"14","USB 2.0-only Type-C Receptacle connector","USB_C_Receptacle_USB2.0","J301","USB_POWER_IN","USB_C_Receptacle_HRO_TYPE-C-31-M-12","1"," ","https://datasheet.lcsc.com/lcsc/2205251630_Korean-Hroparts-E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","C165948",""
"15","Generic connectable mounting pin connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)","Conn_01x04_MountingPin","J401,J501,J601,J1005","cell","JST_XH_S4B-XH-SM4-TB_1x04-1MP_P2.50mm_Horizontal","4"," ","https://datasheet.lcsc.com/lcsc/1810291321_JST-Sales-America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","C2905026","S4B-XH-SM4-TB(LF)(SN)"
"16","Generic connectable mounting pin connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)","Conn_01x04_MountingPin","J901","i2c","PinSocket_1x04_P2.54mm_Vertical","1"," ","~","",""
"17","-4.0A Id, -30V Vds, P-Channel MOSFET, SOT-23","AO3401A","Q301,Q302,Q401,Q501,Q601","AO3401A","SOT-23","5"," ","http://www.aosmd.com/pdfs/datasheet/AO3401A.pdf","C347476","AO3401A"
"18","Resistor","R","R207,R307,R401,R402,R405,R501,R502,R505,R601,R602,R605","100","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","11"," ","~","",""
"19","Resistor","R","R308,R309,R310,R311,R701,R801,R901,R902","4k7","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","8"," ","~","",""
"20","Resistor","R","R203,R205,R206","10k","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","3"," ","~","",""
"21","Resistor","R","R304","15k","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","1"," ","~","",""
"22","Resistor","R","R202,R301","47k","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","2"," ","~","",""
"23","Resistor","R","R201,R302,R305,R403,R406,R503,R506,R603,R606","180k","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","9"," ","~","",""
"24","Resistor","R","R404,R504,R604","200k","R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","3"," ","~","",""
"25","Switch, single pole double throw","SW_SPDT","SW301","SW_SPDT","SW_SPDT_PCM12","1"," ","https://datasheet.lcsc.com/lcsc/1912111437_SHOU-HAN-MSK12C02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","C431540","MSK12C02"
"26","Push button switch, generic, two pins","SW_Push","SW302","btn","PinHeader_1x02_P2.54mm_Vertical","1"," ","~","",""
"27","1A Low Dropout regulator, positive, 3.3V fixed output, SOT-223","AMS1117-3.3","U303","AMS1117-3.3","SOT-223-3_TabPin2","1"," ","http://www.advanced-monolithic.com/pdf/ds1117.pdf","",""
"28","","BMS_USB_LiPo_Charger","U301","BMS_USB_LiPo_Charger","module_bms_usb_lipo_charger","1"," ","","",""
"29","Programmable Resolution 1-Wire Digital Thermometer TO-92","DS18B20","U702,U802","DS18B20","TO-92_Inline","2"," ","http://datasheets.maximintegrated.com/en/ds/DS18B20.pdf","",""
"30","Programmable Resolution 1-Wire Digital Thermometer SOIC-8","DS18B20Z","U701,U801","DS18B20Z","SOIC-8_3.9x4.9mm_P1.27mm","2"," ","http://datasheets.maximintegrated.com/en/ds/DS18B20.pdf","",""
"31","802.11 b/g/n Wi-Fi Module","ESP-07","U201","ESP-7(S) or ESP-12*","ESP-12S","1"," ","https://www.espressif.com/sites/default/files/documentation/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","C89297","ESP-12E"
"32","2-channel, differential, 24-bit ADC, SOP-16 package","HX711","U401,U501,U601","HX711","SOP-16_4.4x10.4mm_P1.27mm","3"," ","https://cdn.sparkfun.com/datasheets/Sensors/ForceFlex/hx711_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","C43656","HX711"
"33","Timer, Nano Power, Active-Low, 35 nA, 100 ms to 7200 s, VDD 1.8V to 5.5V, Iout max 1mA, SOT-23-6","TPL5110","U302","TPL5110","SOT-23-6","1"," ","http://www.ti.com/lit/ds/symlink/tpl5110.pdf","C125830","TPL5110"

## Commit log

2022-11-22 adding initial project
2022-11-22 adding generated files
2022-11-23 extracting load cell adapter to its own page
2022-11-24 various small improvements
2022-11-24 fixing bom, datasheets and adding link to repo
2022-11-25 adding usb port with ldo and diode options
2022-11-26 removing metalization from the hole on the edge for manufacturing
2023-02-05 fixing mode select resistors values, related to #1
2023-02-05 consolidating RST with EN and adding a capacitor for stability. fixes #1
2023-02-05 fixing charging detection divider, fixes #2
2023-02-05 connected LDO USB power with charger USB power, fixes #3
2023-02-05 improving USB-C connector solderability. fixes #4
2023-02-05 adding more labels on silkscreen and bumping up version to 1.1
